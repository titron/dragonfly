# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; Source\include; Source\portable\IAR\ARM_CM3; Common\include; STM32F10xFWLib\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Demo files
    Common/Minimal/: BlockQ.c blocktim.c comtest.c death.c flash.c integer.c PollQ.c semtest.c
    ./: main.c spi_flash.c stm32f10x_it.c timertest.c
    ParTest/: ParTest.c
    serial/: serial.c
  group FreeRTOS files
    Source/portable/MemMang/: heap_2.c
    Source/: list.c queue.c tasks.c
    Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group ST Library
    STM32F10xFWLib/src/: cortexm3_macro.s stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c
  group System files
    ./: stm32f10x_vector.c
