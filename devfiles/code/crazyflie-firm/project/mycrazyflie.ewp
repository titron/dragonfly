# IAR project mycrazyflie.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_MD
  ICCARM.CCDiagSuppress: Pa050,Pe191
  ICCARM.CCIncludePath2: ..\config; ..\drivers\interface; ..\hal\interface; ..\lib\FreeRTOS\include; ..\lib\STM32F10x_StdPeriph_Driver\inc; ..\modules\interface; ..\utils\interface; ..\lib\CMSIS\Core\CM3; ..\lib\FreeRTOS\portable\IAR\ARM-CM3
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\config
  OBJCOPY.OOCOutputFile: mycrazyflie.srec
  ILINK.IlinkOutputFile: mycrazyflie.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f103xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group drivers/src
    ../drivers/src/: adc.c exti.c hmc5883l.c i2cdev.c i2croutines.c led.c motors.c mpu6050.c ms5611.c nrf24l01.c nvic.c
  group hal/src
    ../hal/src/: eskylink.c freeRTOSdebug.c imu.c ledseq.c pm.c radiolink.c uart.c usec_time.c
  group init
    ../init/: main.c
  group lib/CMSIS/core/CM3
    ../lib/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group lib/CMSIS/core/CM3/startup/iar
    ../lib/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_md.s
  group lib/freeRTOS
    ../lib/FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
  group lib/freeRTOS/portable/IAR/ARM-CM3
    ../lib/FreeRTOS/portable/IAR/ARM-CM3/: port.c portasm.s
  group lib/freeRTOS/portable/MemMang
    ../lib/FreeRTOS/portable/MemMang/: heap_2.c
  group lib/STM32F10x_StdLib/src
    ../lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group modules/src
    ../modules/src/: comm.c commander.c console.c controller.c crtp.c crtpservice.c info.c param.c pid.c pidctrl.c sensfusion6.c stabilizer.c system.c worker.c
  group utils/src
    ../utils/src/: abort.c cfassert.c configblock.c cpuid.c crc.c debug.c eprintf.c filter.c fp16.c
